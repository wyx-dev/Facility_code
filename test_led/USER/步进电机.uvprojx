# Keil uVision project 步进电机.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: muban +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\SYSTEM;..\DEVICES\LED;..\DEVICES\MOTOR;..\DEVICES\TIMER;..\DEVICES\EXTI;..\DEVICES\PHOTOELECTRIC;..\USER;..\DEVICES\KEY;..\DEVICES\SERVO;..\DEVICES\HCSR-04;..\DEVICES\USART3;..\DEVICES\SEG;..\DEVICES\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
  group system
    ../SYSTEM/: delay.c sys.c usart.c
  group devices
    ../DEVICES/LED/: led.c
    ../DEVICES/SEG/: seg.c
    ../DEVICES/DS18B20/: ds18b20.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
